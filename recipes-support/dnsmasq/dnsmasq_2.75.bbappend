FILEEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
