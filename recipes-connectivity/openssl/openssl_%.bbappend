
PACKAGECONFIG += "perl"
