FILEEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
#SRC_URI += "file://sshd_config"
