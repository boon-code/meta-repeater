DESCRIPTION = "HTTP library with thread-safe connection pooling, file post, and more."
HOMEPAGE = "https://github.com/shazow/urllib3"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ea114851ad9a8c311aac8728a681a067"

SRC_URI[md5sum] = "34691d4e7e20a8e9cdb452ea24fc38e7"
SRC_URI[sha256sum] = "97ef2b6e2878d84c0126b9f4e608e37a951ca7848e4855a7f7f4437d5c34a72f"

inherit pypi setuptools3
