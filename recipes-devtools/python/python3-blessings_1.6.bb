DESCRIPTION = "A thin, practical wrapper around terminal coloring, styling, and positioning"
HOMEPAGE = "https://github.com/erikrose/blessings"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e6eeaabc92cfc2d03f53e789324d7292"

inherit pypi setuptools3

SRC_URI[md5sum] = "4f552a8ebcd4982693c92571beb99394"
SRC_URI[sha256sum] = "edc5713061f10966048bf6b40d9a514b381e0ba849c64e034c4ef6c1847d3007"
