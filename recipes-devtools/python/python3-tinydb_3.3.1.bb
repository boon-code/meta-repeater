DESCRIPTION = "TinyDB is a tiny, document oriented database optimized for your happiness :)"
HOMEPAGE = "https://github.com/msiemens/tinydb"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;beginline=32;endline=32;md5=534b50804ab5f271b8fc6929c576c5c4"

inherit pypi setuptools3

SRC_URI[md5sum] = "afe9fb80a8b4bc4d5c1ab28cfe3cad2f"
SRC_URI[sha256sum] = "cc18f1b75ea4e1242bc2e5d06ec37814c48071604ca246c31e993e607e8a7319"
