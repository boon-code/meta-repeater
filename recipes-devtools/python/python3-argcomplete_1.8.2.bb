DESCRIPTION = "Bash tab completion for argparse"
HOMEPAGE = "https://github.com/kislyuk/argcomplete"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=2ee41112a44fe7014dce33e26468ba93"

SRC_URI[md5sum] = "1234c0e0db38c5181d8062177361cc4b"
SRC_URI[sha256sum] = "7a2ccde074eb6631232b2f91f8d8d5985d5bebf0e36b091113096e3a0385546b"

inherit pypi setuptools3
