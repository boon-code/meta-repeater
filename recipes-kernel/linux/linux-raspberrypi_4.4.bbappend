FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://rtl8192.cfg"
