FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
        file://rtl8192.cfg \
        file://docker-support.cfg \
        file://rpi3-wifi.cfg \
"
